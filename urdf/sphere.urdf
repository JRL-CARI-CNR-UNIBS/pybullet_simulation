Commit message: little changes

File: urdf/sphere.urdf (robot description, URDF)
Before this commit: robot coke_can_model, 1 links, 0 joints
Links:
- removed link coke_can
- added link sphere, mass 1.0; collision sphere radius=0.01; visual sphere radius=0.01
